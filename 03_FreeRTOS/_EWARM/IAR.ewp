# IAR project IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32G474RE ST STM32G474RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32G474xx
  ICCARM.CCIncludePath2: ..\; ..\CMSIS\Include; ..\FreeRTOS\; ..\FreeRTOS\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR.bin
  ILINK.IlinkOutputFile: IAR.out
  ILINK.IlinkIcfFile: stm32g474xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c
  group _EWARM
    ./: startup_stm32g474xx.s stm32g474xx_flash.icf
  group CMSIS/Device
    ../CMSIS/Device/: stm32g474xx.h stm32g4xx.h system_stm32g4xx.c system_stm32g4xx.h
  group CMSIS/Include
    ../CMSIS/Include/: cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
  group FreeRTOS
    ../FreeRTOS/: FreeRTOSConfig.h port.c portasm.s portmacro.h
  group FreeRTOS/include
    ../FreeRTOS/include/: deprecated_definitions.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group FreeRTOS/src
    ../FreeRTOS/src/: heap_2.c list.c queue.c tasks.c timers.c
  group user/inc
    ../user/inc/: RCC.h
  group user/src
    ../user/src/: RCC.c
